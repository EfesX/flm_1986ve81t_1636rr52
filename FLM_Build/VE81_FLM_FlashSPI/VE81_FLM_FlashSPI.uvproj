# Keil uVision project VE81_FLM_FlashSPI.uvproj, settings and files
target Cortex-M (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: Z:\_Projects\milandr\myFLM_2\src
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
    ../../src/: 1636RR52.c
  group Device Description
    ./: FlashDev.c
  group Stack Size
    ./: FlashStk.s
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLX"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
